* /Users/locutus/Dropbox/Electronics/Tic-Tac-Toe Arduino/Tic-Tac-Toe Arduino.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: Saturday, August 13, 2016 'PMt' 07:23:14 PM

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
D2  Net-_D1-Pad2_ Net-_D1-Pad1_ LED
D12  Net-_D11-Pad2_ Net-_D1-Pad2_ LED
D4  Net-_D10-Pad1_ Net-_D1-Pad2_ LED
D11  Net-_D1-Pad2_ Net-_D11-Pad2_ LED
D18  Net-_D13-Pad2_ Net-_D1-Pad2_ LED
D6  Net-_D11-Pad2_ Net-_D10-Pad1_ LED
D5  Net-_D10-Pad1_ Net-_D11-Pad2_ LED
D15  Net-_D1-Pad1_ Net-_D11-Pad2_ LED
D16  Net-_D11-Pad2_ Net-_D1-Pad1_ LED
D1  Net-_D1-Pad1_ Net-_D1-Pad2_ LED
D19  Net-_D1-Pad1_ Net-_D13-Pad2_ LED
D7  Net-_D11-Pad2_ Net-_D13-Pad2_ LED
D13  Net-_D10-Pad1_ Net-_D13-Pad2_ LED
D10  Net-_D10-Pad1_ Net-_D1-Pad1_ LED
D9  Net-_D1-Pad1_ Net-_D10-Pad1_ LED
D3  Net-_D1-Pad2_ Net-_D10-Pad1_ LED
D17  Net-_D1-Pad2_ Net-_D13-Pad2_ LED
D20  Net-_D13-Pad2_ Net-_D1-Pad1_ LED
SW5  Net-_R6-Pad2_ Net-_R5-Pad2_ SW_PUSH
SW6  Net-_R5-Pad1_ Net-_R4-Pad2_ SW_PUSH
SW7  Net-_R4-Pad1_ Net-_R3-Pad1_ SW_PUSH
SW8  Net-_R6-Pad1_ Net-_R7-Pad2_ SW_PUSH
SW9  Net-_R7-Pad1_ Net-_R8-Pad2_ SW_PUSH
SW10  Net-_R8-Pad1_ Net-_R9-Pad2_ SW_PUSH
SW2  Net-_P1-Pad10_ Net-_R1-Pad2_ SW_PUSH
SW3  Net-_R1-Pad1_ Net-_R2-Pad2_ SW_PUSH
SW4  Net-_R2-Pad1_ Net-_R3-Pad2_ SW_PUSH
R15  Net-_P1-Pad2_ Net-_D13-Pad2_ 120K
R14  Net-_P1-Pad3_ Net-_D11-Pad2_ 120K
R13  Net-_P1-Pad4_ Net-_D10-Pad1_ 120K
R12  Net-_P1-Pad5_ Net-_D1-Pad2_ 120K
R11  Net-_P1-Pad6_ Net-_D1-Pad1_ 120K
R1  Net-_R1-Pad1_ Net-_R1-Pad2_ 100R
R2  Net-_R2-Pad1_ Net-_R2-Pad2_ 100R
R6  Net-_R6-Pad1_ Net-_R6-Pad2_ 100R
R5  Net-_R5-Pad1_ Net-_R5-Pad2_ 100R
R9  Net-_R9-Pad1_ Net-_R9-Pad2_ 100R
R7  Net-_R7-Pad1_ Net-_R7-Pad2_ 100R
R8  Net-_R8-Pad1_ Net-_R8-Pad2_ 100R
R4  Net-_R4-Pad1_ Net-_R4-Pad2_ 100R
R3  Net-_R3-Pad1_ Net-_R3-Pad2_ 100R
D14  Net-_D13-Pad2_ Net-_D10-Pad1_ LED
D8  Net-_D13-Pad2_ Net-_D11-Pad2_ LED
SW1  Net-_R10-Pad1_ Net-_R9-Pad1_ SW_PUSH
R10  Net-_R10-Pad1_ Net-_P1-Pad9_ 100R
SW11  Net-_P1-Pad8_ Net-_P1-Pad7_ ? Switch_SPDT_x2
P1  ? Net-_P1-Pad2_ Net-_P1-Pad3_ Net-_P1-Pad4_ Net-_P1-Pad5_ Net-_P1-Pad6_ Net-_P1-Pad7_ Net-_P1-Pad8_ Net-_P1-Pad9_ Net-_P1-Pad10_ CONN_01X10

.end
